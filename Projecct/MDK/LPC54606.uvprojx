# Keil uVision project LPC54606.uvprojx, settings and files
target LPC54606 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: LPC54606J512BD100 NXP
  pack: NXP.LPC54606_DFP.11.0.0
  cpu: IRAM(0x04000000,0x8000) IRAM2(0x20000000,0x028000) IROM(0x40108000,0x4000) IROM2(0x00000000,0x080000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC54606 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\drives\common;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\CODE\Control;..\CODE\Handle;..\CODE\PID;..\CODE\System;..\CODE\DaJin;..\CODE\SiYuanSu
  memory RVCT4: ROM 0x40108000 size 0x4000
  memory RVCT5: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x4000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x28000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_LPC54606.s
    ../../Libraries/startup/DeviceSupport/: system_LPC54606.c system_LPC54606.h
  group common
    ../../Libraries/drives/common/: common.c common.h assert.c assert.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group drives_h
    ../../Libraries/drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_eeprom.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_mrt.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h
  group drives_c
    ../../Libraries/drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_mrt.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c
  group user_h
    ../USER/inc/: headfile.h isr.h LPC546XX_config.h
  group user_c
    ../USER/src/: isr.c main.c
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_7725.c SEEKFREE_7725.h
  group code
    ../CODE/Control/: Control.c
    ../CODE/Handle/: Handle.c
    ../CODE/PID/: PID.c
    ../CODE/System/: System.c
    ../CODE/DaJin/: DaJin.c
    ../CODE/SiYuanSu/: siyuansu.c
